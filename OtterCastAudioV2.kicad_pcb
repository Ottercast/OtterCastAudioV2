# Repository Ottercast/OtterCastAudioV2

File README.md:

# OtterCastAudioV2

OtterCast is an open-source audio streaming device running Linux.
Based on a Sochip S3 SoC, featuring a Webinterface, shairport-sync, snapcast, Spotify Connect and pulseaudio sink/source.

## How do I get one?

~We are currently planning a small batch production run, stay tuned.~ No we are not, sorry

You don't want to wait? You can of course run a small batch on your own! Please have a look into the [production folder](/production_v2.1.1), a batch size of just 5 (and up to 30) boards is supported by JLC.

## Installation & Configuration

After [downloading and flashing](https://cast.otter.jetzt/docs/firmware/#download-ready-made-images) the image, OtterCastAudio can either be configured via the `config.ini` file or via the web-interface.

Check out our [Documentation](https://cast.otter.jetzt/docs/) for more information!

## Schematics?

[Schematics!](/OtterCastAudioV2.pdf)

## Team

 - [@lucysrausch](https://twitter.com/lucysrausch) Hardware - OtterCastAmp
 - [@janamarie](https://chaos.social/@janamarie) Hardware - OtterCastAudio
 - [@Toble_Miner](https://twitter.com/Toble_Miner) Software - Embedded Linux
 - [@Manawyrm](https://twitter.com/Manawyrm) Software - Frontend & OTA

## What happened to OtterCastAudioV1?

Nobody shall ever know

## Status

HW v2.1 is tested and works!

 - [x] Audio Line Out
 - [x] Audio Headphone Out
 - [x] Audio In
 - [x] WiFi
 - [x] Ethernet
 - [x] USB Sound card mode

 - [x] Webinterface (config)
 - [x] Shairport-sync
 - [x] Pulseaudio sink/source
 - [x] snapcast server/client
 - [x] Spotify Connect (librespot)

## License

## KiCad design OtterCastAudioV2.kicad_pcb

Board: 4 copper layers, 50.0 x 49.3 mm, 216 parts (7 on the bottom side), 149 nets.

Parts:
AE1: KH-5220-A56_U.FL; KH-5220-A56
C1, C4, C6, C14, C16, C17, C19, C20, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C39, C41, C48, C72, C74, C90, C92, C95: 10u; C_0603
C2: 470n; C_0402
C3, C7, C8, C15, C18, C21, C32, C33, C34, C35, C36, C37, C38, C44, C58, C59, C61, C65, C66, C73, C76, C82, C83, C85, C88, C89, C98, C100, C101, C102, C103: 100n; C_0402
C5, C10, C11, C42, C43, C45: 47u; C_0805
C9: 2.2u; C_0603
C12, C47: 1n; C_0402
C13, C104: 1n; C_0805
C46, C50, C53, C70, C71: 220p; C_0402
C49: DNP; C_0402
C51, C52, C93, C94, C96, C97: 18p; C_0402
C54, C55, C56, C57, C60, C62, C63, C64, C69: 10u; CP_EIA-3216-10
C67, C68: 100u; CP_EIA-3528-12
C75, C77: 1p; C_0402
C78: 10p; C_0402
D1, D2: LED; LED_0603_1608Metric
D3: LED; LED_0603_1608Metric_Castellated
D4: P6SMB6.8CA; D_SMB
D5, D6: ESD5302F; SOT-23
FB1, FB2, FB3: FERRET; R_0805
J1: UART; PinHeader_1x04_P2.00mm_Vertical_nosilk_center
J2: SD; microSD_HC_Hirose_DM3D-SF
J3: USB; USB-C 16Pin
J4: OTG; PinHeader_1x04_P2.00mm_Vertical_nosilk_center
J5, J6, J7: PJ-3270
J8: 49F-1201GYD2NL; 49F-1201GYDXNL
L1, L2, L3, L4: 2.2uH; L_Taiyo-Yuden_MD-3030
L5: 2.2nH; L_0402
MK1: Mic; B4013AM422-42
Q1: DTA114YKA; SOT-23
R1, R32, R33, R61, R62: 100; R_0402
R2, R15, R34, R54, R76, R77, R81: 22; R_0402
R3, R4, R14, R24, R25, R30, R35, R36, R39, R86: 5k1; R_0402
R6, R22, R23, R29, R47, R52, R66, R67, R68, R69: DNP; R_0402
R7, R8, R9, R10, R11, R12, R13, R18, R26, R42, R58, R59, R60, R63, R64, R65, R70, R71, R72, R73, R74, R75: 47k; R_0402
R16, R21, R40, R78: 200k; R_0402
R17, R28, R37, R41, R48, R49, R50, R51, R79, R80, R87, R88: 2k2; R_0402
R27: 0R; R_0805
R31: 3k3; R_0402
R38: 3k9; R_0402
R43: 680; R_0402
R44, R45, R46: 0; R_0402
R82, R83: 240; R_0402
R84: 10M; R_0402
R89: 6k04; R_0402
R90, R91, R92, R93: 51; R_0402
SW3: RST; SW_SPST_PTS810
U1: AllWinner-S3(FBGA-234); FBGA-234(Pitch-0.65mm_Pad-0.3mm_11x11x1.08mm)
U3: AXP209(QFN-48); QFN-48-1EP_6x6mm_P0.4mm_EP4.05x4.05mm
U4: SY8089AAAC; SOT-23-5
U5: SY6280AAC; SOT-23-5
U6: SSM2603; LFCSP-28-5x5mm-0.5mm-EP3.14x3.14mm
U7: AP6236; LGA_44_12x12mm_0.9mm
X1: 26Mhz TCXO; 2016_SMD_CRYSTAL
Y1: 12.288Mhz; Oscillator_3225
Y2: 32.768kHz; Crystal_SMD_3215-2Pin_3.2x1.5mm
Y3: 24MHz; Oscillator_3225

Connections:
+1V1: C18.1, C22.1, C33.1, C35.1, C36.1, C39.1, C92.1, L2.2, U1.G12, U1.H12, U1.J11, U1.J12, U1.K8, U1.K9, U1.K11, U1.L8, U1.M8, U1.N5, U3.10
+1V2: C27.1, U3.41
+2V5: C7.1, U3.19
+2V8: C29.1, U3.11
+3.0VA: C26.1, C60.1, C65.1, C89.1, FB2.2, FB3.2, R40.1, U1.L6, U1.M7, U3.12, U4.1, U6.5
+3.3V_RTC: C25.1, C98.1, R18.2, R26.1, R86.2, U1.N6, U3.28, U3.29
+3V3: C1.1, C21.1, C23.1, C38.1, C62.1, C66.1, C72.1, C73.1, C74.1, C76.1, C95.1, FB1.1, J1.4, J8.9, J8.11, L1.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R48.2, R49.2, R50.2, R51.2, R64.1, R65.1, R70.1, R71.1, R72.1, R73.1, R74.1, R75.1, U1.H11, U1.L11, U1.L12, U1.M4, U1.M5, U1.M11, U1.M12, U1.N7, U1.P5, U1.P12, U3.17, U6.3, U7.9, U7.22, X1.4
+5V: C11.1, C14.1, C42.1, D4.1, J3.A4, J3.A9, J3.B4, J3.B9, R14.2, U3.32, U3.33, U5.5
+5V_USBOTG: C6.1, C43.1, C45.1, J4.4, R37.1, U3.31, U5.1
/Power/NMI: R18.1, U3.48
AP_CK32KO: R76.1, R86.1, U1.P3
AP_WAKE_BT: U1.F12, U7.6
BT_DIS_N: R2.2, U7.34
BT_PCM_CLK: R67.1, U1.P14, U6.7
BT_PCM_DIN: R68.1, U1.M13, U6.10
BT_PCM_DOUT: R69.1, U1.T15, U6.8
BT_PCM_SYNC: R54.2, R66.1, U1.T14, U6.9
BT_UART_CTS: U1.B8, U7.44
BT_UART_RTS: U1.C4, U7.41
BT_UART_RX: R74.2, U1.B3, U7.43
BT_UART_TX: U1.B4, U7.42
BT_WAKE_AP: R75.2, U1.N14, U7.7
EPHY_LINK_LED: R87.1, U1.K5
EPHY_RX_N: J8.2, R90.1, U1.F1
EPHY_RX_P: J8.1, R91.1, U1.F2
EPHY_SPD_LED: R88.1, U1.L5
EPHY_TX_N: J8.8, R92.1, U1.E2
EPHY_TX_P: J8.7, R93.1, U1.E3
GND: AE1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.1, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C41.2, C42.2, C43.2, C44.2, C45.2, C48.2, C49.2, C51.2, C52.2, C60.2, C61.2, C62.2, C65.2, C66.2, C69.2, C72.2, C73.2, C74.2, C75.1, C76.2, C77.1, C83.2, C85.2, C88.2, C89.2, C90.2, C92.2, C93.2, C94.2, C95.2, C96.2, C97.2, C98.2, C100.1, C101.1, C102.1, C103.1, C104.2, D1.1, D2.1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
GNDA: C46.2, C50.2, C53.2, C54.2, C55.2, C58.2, C59.2, C70.2, C71.2, J5.4, J6.4, J7.4, MK1.1, R27.2, R42.2, R47.2, R52.2, R58.1, R59.2, R60.1, R63.2, U6.15, U6.19
GPIO_LED1: R3.1, U1.C7
GPIO_LED2: R4.1, U1.C8
GPIO_RST: R6.2, SW3.2, U1.A2
IPS: C5.1, C8.1, C10.1, C16.1, C17.1, C19.1, C20.1, C24.1, C28.1, C30.1, Q1.2, U3.7, U3.13, U3.14, U3.21, U3.34, U3.35, U3.40, U3.44, U4.4
MIC_DET: R40.2, R41.1, U1.B5
MIPI_SCK: R51.1, U1.G16, U3.2, U6.28
MIPI_SDA: R50.1, U1.J16, U3.1, U6.27
unnamed: AE1.1, C75.2, L5.1
unnamed: C3.1, R78.1, U1.N10
unnamed: C4.1, FB1.2, J2.4
unnamed: C9.2, U3.24
unnamed: C12.1, U3.47
unnamed: C13.1, J3.S1, R21.1
unnamed: C15.1, U3.38, U3.39, U3.42
unnamed: C46.1, C47.2, MK1.2, R42.1, R43.1
unnamed: C47.1, R46.1
unnamed: C48.1, C49.1, L4.1, U7.23
unnamed: C50.1, C57.2, R45.2, R47.1
unnamed: C51.1, U6.1, Y1.3
unnamed: C52.1, U6.2, Y1.1
unnamed: C53.1, C56.2, R44.2, R52.1
unnamed: C54.1, C58.1, FB3.1, U6.18
unnamed: C55.1, C59.1, FB2.1, U6.12
unnamed: C56.1, U6.24
unnamed: C57.1, U6.23
unnamed: C61.1, C69.1, U6.20
unnamed: C63.1, U6.17
unnamed: C63.2, R58.2, R61.2
unnamed: C64.1, U6.16
unnamed: C64.2, R60.2, R62.2
unnamed: C67.1, U6.14
unnamed: C67.2, C71.1, J6.5, R63.1
unnamed: C68.1, U6.13
unnamed: C68.2, C70.1, J6.2, R59.1
unnamed: C77.2, C78.1, L5.2
unnamed: C78.2, U7.2
unnamed: C82.1, C83.1, C88.1, R79.1, R80.1, U1.H6
unnamed: C85.1, U1.M9
unnamed: C90.1, U1.T5
unnamed: C93.1, U1.R4, Y3.1
unnamed: C94.1, U1.P4, Y3.3
unnamed: C96.1, R84.2, U1.T3, Y2.1
unnamed: C97.1, R84.1, U1.R3, Y2.2
unnamed: C100.2, R90.2, R91.2
unnamed: C101.2, R92.2, R93.2
unnamed: C102.2, J8.3
unnamed: C103.2, J8.6
unnamed: C104.1, J8.SH
unnamed: D1.2, R3.2
unnamed: D2.2, R4.2
unnamed: D3.2, R14.1
unnamed: D5.1, J1.3, R33.1
unnamed: D5.2, J1.2, R1.1
unnamed: J3.A5, R24.1
unnamed: J3.A6, J3.B6, R23.1
unnamed: J3.A7, J3.B7, R22.1
unnamed: J3.B5, R25.1
unnamed: J5.2, R44.1
unnamed: J5.3, R41.2
unnamed: J5.5, R45.1
unnamed: J7.2, R62.1
unnamed: J7.5, R61.1
unnamed: J8.10, R88.2
unnamed: J8.12, R87.2
unnamed: L1.1, U3.15
unnamed: L2.1, U3.8
unnamed: L3.1, U4.3
unnamed: L4.2, U7.21
unnamed: Q1.1, R6.1
unnamed: Q1.3, R17.1, U3.4
unnamed: R2.1, U1.C13
unnamed: R15.1, U3.37
unnamed: R16.1, U3.23
unnamed: R28.2, R29.2, U3.27
unnamed: R30.2, R31.1, U4.5
unnamed: R31.2, R32.1
unnamed: R34.1, U1.M6
unnamed: R36.1, U5.3
unnamed: R43.2, U6.21
unnamed: R46.2, U6.22
unnamed: R48.1, U6.25
unnamed: R49.1, U6.26
unnamed: R54.1, U6.11
unnamed: R66.2, U7.28
unnamed: R67.2, U7.26
unnamed: R68.2, U7.27
unnamed: R69.2, U7.25
unnamed: R76.2, U7.24
unnamed: R77.2, U7.17
unnamed: R81.1, U1.R13
unnamed: R82.1, U1.J5
unnamed: R83.1, U1.F5
unnamed: R89.2, U1.P6
unnamed: U7.10, X1.3
RESETn: C2.1, R26.2, U1.P7, U3.25
SDC0_CLK: J2.5, R10.1, U1.P2
SDC0_CMD: J2.3, R9.1, U1.N2
SDC0_D0: J2.7, R11.1, U1.P1
SDC0_D1: J2.8, R12.1, U1.R1
SDC0_D2: J2.1, R7.1, U1.M2
SDC0_D3: J2.2, R8.1, U1.N3
SDC0_DET#: J2.10, R13.1, U1.M1
UART1_RX: R1.2, U1.M14
UART1_TX: R33.2, U1.M15
USB_DRV: R35.1, U3.6, U5.4
USB_D_N: D6.2, J4.3, R22.2, U1.R2
USB_D_P: D6.1, J4.2, R23.2, U1.T2
USB_ID: R39.2, U1.R14
USB_VBUSDET: C44.1, R37.2, R38.1, U1.A5
VCC-DDR: C31.1, C32.1, C34.1, C37.1, C41.1, C82.2, L3.2, R30.1, R79.2, U1.F6, U1.F7, U1.F8, U1.G8, U1.H8, U1.J8
VINT: R28.1, U3.26
WL_PMU_EN: R73.2, U1.E16, U7.12
WL_SDIO_CLK: R77.1, U1.P16
WL_SDIO_CMD: R72.2, U1.N15, U7.16
WL_SDIO_D0: R71.2, U1.P15, U7.18
WL_SDIO_D1: R70.2, U1.N16, U7.19
WL_SDIO_D2: R65.2, U1.R15, U7.14
WL_SDIO_D3: R64.2, U1.R16, U7.15
WL_WAKE_AP: U1.C5, U7.13

File gerber_v2.0/BOM.csv:

Comment,Designator,Footprint, LCSC
KH-5220-A56_U.FL,AE1,otter:KH-5220-A56,C504003
47u,"C11,C10,C5,C42,C43,C45",otter:C_0805,C45783
1n,"C12,C47",otter:C_0402,C1523
1n,"C13,C104",otter:C_0805,C46653
100n,"C37,C38,C35,C36,C33,C34,C32,C44,C7,C8,C15,C21,C18,C58,C59,C66,C65,C61,C76,C73,C89,C99,C98,C102,C103,C88,C82,C85,C101,C100,C83,C3",otter:C_0402,C1525
10u,"C4,C1,C17,C16,C22,C23,C20,C19,C24,C25,C26,C27,C28,C29,C14,C6,C39,C41,C30,C31,C74,C72,C48,C92,C95,C90,C79",otter:C_0603,C19702
DNP,C49,otter:C_0402,dnp
18p,"C52,C51,C93,C94,C96,C97",otter:C_0402,C1549
10u,"C54,C55,C62,C60,C63,C64,C57,C56,C69",otter:CP_EIA-3216-10,C7171
100u,"C67,C68",otter:CP_EIA-3528-12,C16133
220p,"C70,C71,C50,C53,C46",otter:C_0402,C1530
1p,"C77,C75",otter:C_0402,C1550
10p,C78,otter:C_0402,C32949
2.2u,C9,otter:C_0603,C23630
LED,D1,otter:LED_0603_1608Metric,C72038
LED,"D2,D3",LED_SMD:LED_0603_1608Metric_Castellated,C72043
P6SMB6.8CA,D4,Diode_SMD:D_SMB,C78395
ESD5302F,"D5,D6",Package_TO_SOT_SMD:SOT-23,C239643
FERRET,"FB1,FB2,FB3",otter:R_0805,C1017
UART,J1,otter:PinHeader_1x04_P2.00mm_Vertical_nosilk_center,dnp
SD,J2,Connector_Card:microSD_HC_Hirose_DM3D-SF,order
USB,J3,otter:USB-C 16Pin,order
OTG,J4,otter:PinHeader_1x04_P2.00mm_Vertical_nosilk_center,dnp
PJ-3270,"J7,J6,J5",otter:PJ-3270,order
49F-1201GYD2NL,J8,otter:49F-1201GYDXNL,order
2.2uH,"L2,L1,L3,L4",Inductor_SMD:L_Taiyo-Yuden_MD-3030,C167747
2.2uH,L5,otter:L_0402,C84472
Mic,MK1,otter:B4013AM422-42,order
DTA114YKA,Q1,Package_TO_SOT_SMD:SOT-23,C111713
100,"R1,R33,R32,R61,R62",otter:R_0402,C25076
200k,"R16,R21,R40,R78",otter:R_0402,C25764
DNP,"R2,R29,R22,R23,R47,R52,R69,R68,R67,R66",otter:R_0402,dnp
0R,R27,otter:R_0805,C17477
5k1,"R3,R4,R35,R36,R39,R24,R25,R14,R86,R30",otter:R_0402,C25905
3k3,R31,otter:R_0402,C25890
22,"R34,R15,R54,R77,R76,R81",otter:R_0402,C25092
2k2,"R37,R41,R87,R88,R79,R80,R5,R6,R28,R19,R20,R17,R50,R51,R49,R48",otter:R_0402,C25879
3k9,R38,otter:R_0402,C51721
680,R43,otter:R_0402,C25130
0,"R44,R45,R46",otter:R_0402,C17168
47k,"R7,R8,R9,R10,R11,R12,R13,R26,R18,R58,R60,R59,R63,R42,R73,R72,R71,R70,R65,R64,R75,R74",otter:R_0402,C25792
240,"R82,R83",otter:R_0402,C25094
10M,R84,otter:R_0402,C26082
6k04,R89,otter:R_0402,order
51,"R91,R90,R93,R92,R94",otter:R_0402,C25125
DNP,"SW2,SW1",otter:SW_SPST_PTS810,dnp
RST,SW3,otter:SW_SPST_PTS810,order
AllWinner-S3(FBGA-234),U1,otter:FBGA-234(Pitch-0.65mm_Pad-0.3mm_11x11x1.08mm),order
AT24CS16-MAHM,U2,Package_DFN_QFN:DFN-8-1EP_3x2mm_P0.5mm_EP1.3x1.5mm,order
AXP209(QFN-48),U3,otter:QFN-48-1EP_6x6mm_P0.4mm_EP4.05x4.05mm,order
SY8089AAAC,U4,Package_TO_SOT_SMD:SOT-23-5,C78988
SY6280AAC,U5,Package_TO_SOT_SMD:SOT-23-5,SY6280AAC
SSM2603,U6,otter:LFCSP-28-5x5mm-0.5mm-EP3.14x3.14mm,order
AP6236,U7,otter:LGA_44_12x12mm_0.9mm,order
26Mhz TCXO,X1,otter:2016_SMD_CRYSTAL,C132147
12.288Mhz,Y1,otter:Oscillator_3225,C70567
32.768kHz,Y2,otter:Crystal_SMD_3215-2Pin_3.2x1.5mm,C32346
24MHz,Y3,otter:Oscillator_3225,C124301

## Commit log

2020-11-17 no drc error
2020-11-18 working on silkscreen
2020-11-19 regenerated gerber
2020-11-19 added edgerails and production files
2021-02-12 merge
2021-02-12 added images
2021-02-12 fixed axp bug, fixed schematics, fixed eeprom
2021-02-14 fixed ETH, added AGND plane to prevent Line-In Noise, optimized power
2021-02-14 fixed ETH cur ref
2021-02-18 fixed axp rst, gpio rst, din, dout, eth
2021-02-18 removed 3d files
2021-02-18 added gitignore, finished v2.1, exported gerber, moved 2.0 data
2021-02-19 added i2c to axp209, fixed tvs diodes
2021-02-19 changed RST to cfg
2021-02-19 finalized v2.1, ordered boards
2021-02-19 updated graphics file
2021-02-27 removed old libs
2021-02-27 broken links
2021-03-01 beautify kicad project
2021-03-01 remove cached files
2021-03-01 exported pdf
2021-03-09 added cad
2021-03-09 removed ibom
2021-03-09 moved file
2021-03-09 removed scad file
2021-03-23 added readme, removed old files
2021-03-24 renamed folder
2021-03-24 fixed typos
2021-04-06 Create LICENSE
2021-04-07 added ordering images
2021-04-16 added license img, updated readme
2021-04-19 fixed typo, added installation
2021-06-25 Add kitspace.yaml
2021-10-30 Update 26Mhz TCXO LCSC in BOM
    matches LCSC Part# in README
2021-10-30 Add Microphone LCSC to BOM
2022-02-14 updated license
2022-04-01 updated to kicad 6
2022-04-01 deleted old files
2022-04-01 updated files to kicad 6
2022-04-01 updated gitignore
2023-07-04 Update LICENSE
2023-09-22 Update parts in readme to have correct/updated links
2023-10-06 renamed and updated jlcpcb documentation
2024-01-16 updated bom and pos
2024-01-16 updated kicad files
2024-01-16 added bottom pos
2024-04-11 updated kicad files to v2.1.1, updated license
2024-04-11 updated production files
2024-04-11 udpated gitignore
2024-04-11 updated edgerails
2025-01-14 Minor fixes
    Fixed HW production link and reference to OttercastAMP

File: Power.sch (KiCad schematic (older format))
At the start: 81 parts, among them J3 USB, J4 OTG, Q1 DTA114YKA, SW1 DNP, SW2 DNP, SW3 RST, U1 AllWinner-S3(FBGA-234), U3 AXP209(QFN-48), U4 SY8089AAAC, U5 SY6280AAC

Commit message: update
Parts:
- removed C40: 10u, otter:C_0603, symbol Device:C_Small
Changed lines of the file:
@@
-$Comp
-L Device:C_Small C?
-U 1 1 68F8B62E
-P 11100 3650
-AR Path="/68F8B62E" Ref="C?"  Part="1"
-AR Path="/602ACDF9/68F8B62E" Ref="C40"  Part="1"
-F 0 "C40" H 10900 3700 50  0000 L CNN
-F 1 "10u" H 10900 3600 50  0000 L CNN
-F 2 "otter:C_0603" H 11100 3650 50  0001 C CNN
-F 3 "~" H 11100 3650 50  0001 C CNN
-	1    11100 3650
-	1    0    0    -1
-$EndComp
 $Comp
 L Device:C_Small C?

Commit message: no drc error
Parts:
- R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R28, R29, R30, R31, R32, R34, R35, R36, R37, R38, R39: footprint otter:C_0402 -> otter:R_0402
Changed lines of the file:
@@
 F 0 "R34" V 10700 4650 50  0000 C CNN
 F 1 "22" V 10700 4950 50  0000 C CNN
-F 2 "otter:C_0402" H 10750 4800 50  0001 C CNN
+F 2 "otter:R_0402" H 10750 4800 50  0001 C CNN
 F 3 "~" H 10750 4800 50  0001 C CNN
 	1    10750 4800
@@
 F 0 "R26" V 4854 5550 50  0000 C CNN
 F 1 "47k" V 4945 5550 50  0000 C CNN
-F 2 "otter:C_0402" H 5050 5550 50  0001 C CNN
+F 2 "otter:R_0402" H 5050 5550 50  0001 C CNN
 F 3 "~" H 5050 5550 50  0001 C CNN
 	1    5050 5550
@@
 F 0 "R28" V 5350 5600 50  0000 C CNN
 F 1 "2.2k" V 5350 5950 50  0000 C CNN
-F 2 "otter:C_0402" H 5400 5750 50  0001 C CNN
+F 2 "otter:R_0402" H 5400 5750 50  0001 C CNN
 F 3 "~" H 5400 5750 50  0001 C CNN
 	1    5400 5750
@@
 F 0 "R29" V 5350 5700 50  0000 C CNN
 F 1 "DNP" V 5350 6050 50  0000 C CNN
-F 2 "otter:C_0402" H 5400 5850 50  0001 C CNN
+F 2 "otter:R_0402" H 5400 5850 50  0001 C CNN
 F 3 "~" H 5400 5850 50  0001 C CNN
 	1    5400 5850
@@
 F 0 "R19" V 2000 5700 50  0000 C CNN
 F 1 "2.2k" V 2000 6050 50  0000 C CNN
-F 2 "otter:C_0402" H 2050 5850 50  0001 C CNN
+F 2 "otter:R_0402" H 2050 5850 50  0001 C CNN
 F 3 "~" H 2050 5850 50  0001 C CNN
 	1    2050 5850
@@
 F 0 "R20" V 2000 5800 50  0000 C CNN
 F 1 "2.2k" V 2000 6150 50  0000 C CNN
-F 2 "otter:C_0402" H 2050 5950 50  0001 C CNN
+F 2 "otter:R_0402" H 2050 5950 50  0001 C CNN
 F 3 "~" H 2050 5950 50  0001 C CNN
 	1    2050 5950
@@
 F 0 "R18" V 2000 5600 50  0000 C CNN
 F 1 "47k" V 2000 5950 50  0000 C CNN
-F 2 "otter:C_0402" H 2050 5750 50  0001 C CNN
+F 2 "otter:R_0402" H 2050 5750 50  0001 C CNN
 F 3 "~" H 2050 5750 50  0001 C CNN
 	1    2050 5750
@@
 F 0 "R17" V 2000 5400 50  0000 C CNN
 F 1 "2.2k" V 2000 5750 50  0000 C CNN
-F 2 "otter:C_0402" H 2050 5550 50  0001 C CNN
+F 2 "otter:R_0402" H 2050 5550 50  0001 C CNN
 F 3 "~" H 2050 5550 50  0001 C CNN
 	1    2050 5550
@@
 F 0 "R16" V 1900 3700 50  0000 C CNN
 F 1 "200k" V 1900 4050 50  0000 C CNN
-F 2 "otter:C_0402" H 1950 3850 50  0001 C CNN
+F 2 "otter:R_0402" H 1950 3850 50  0001 C CNN
 F 3 "~" H 1950 3850 50  0001 C CNN
 	1    1950 3850
@@
 F 0 "R15" V 1754 1250 50  0000 C CNN
 F 1 "22" V 1845 1250 50  0000 C CNN
-F 2 "otter:C_0402" H 1950 1250 50  0001 C CNN
+F 2 "otter:R_0402" H 1950 1250 50  0001 C CNN
 F 3 "~" H 1950 1250 50  0001 C CNN
 	1    1950 1250
@@
 F 0 "R30" H 8209 8196 50  0000 L CNN
 F 1 "5.1k" H 8209 8105 50  0000 L CNN
-F 2 "otter:C_0402" H 8150 8150 50  0001 C CNN
+F 2 "otter:R_0402" H 8150 8150 50  0001 C CNN
 F 3 "~" H 8150 8150 50  0001 C CNN
 	1    8150 8150
@@
 F 0 "R31" H 8209 8496 50  0000 L CNN
 F 1 "3.3k" H 8209 8405 50  0000 L CNN
-F 2 "otter:C_0402" H 8150 8450 50  0001 C CNN
+F 2 "otter:R_0402" H 8150 8450 50  0001 C CNN
 F 3 "~" H 8150 8450 50  0001 C CNN
 	1    8150 8450
@@
 F 0 "R32" H 8209 8696 50  0000 L CNN
 F 1 "100" H 8209 8605 50  0000 L CNN
-F 2 "otter:C_0402" H 8150 8650 50  0001 C CNN
+F 2 "otter:R_0402" H 8150 8650 50  0001 C CNN
 F 3 "~" H 8150 8650 50  0001 C CNN
 	1    8150 8650
@@
 F 0 "R35" H 11341 8696 50  0000 R CNN
 F 1 "5k1" H 11341 8605 50  0000 R CNN
-F 2 "otter:C_0402" H 11400 8650 50  0001 C CNN
+F 2 "otter:R_0402" H 11400 8650 50  0001 C CNN
 F 3 "~" H 11400 8650 50  0001 C CNN
 	1    11400 8650
@@
 F 0 "R36" H 12409 8196 50  0000 L CNN
 F 1 "5k1" H 12409 8105 50  0000 L CNN
-F 2 "otter:C_0402" H 12350 8150 50  0001 C CNN
+F 2 "otter:R_0402" H 12350 8150 50  0001 C CNN
 F 3 "~" H 12350 8150 50  0001 C CNN
 	1    12350 8150
@@
 F 0 "R37" H 12709 8146 50  0000 L CNN
 F 1 "2k2" H 12709 8055 50  0000 L CNN
-F 2 "otter:C_0402" H 12650 8100 50  0001 C CNN
+F 2 "otter:R_0402" H 12650 8100 50  0001 C CNN
 F 3 "~" H 12650 8100 50  0001 C CNN
 	1    12650 8100
@@
 F 0 "R38" H 12591 8746 50  0000 R CNN
 F 1 "3k9" H 12591 8655 50  0000 R CNN
-F 2 "otter:C_0402" H 12650 8700 50  0001 C CNN
+F 2 "otter:R_0402" H 12650 8700 50  0001 C CNN
 F 3 "~" H 12650 8700 50  0001 C CNN
 	1    12650 8700
@@
 F 0 "R39" H 14541 8154 50  0000 R CNN
 F 1 "5k1" H 14541 8245 50  0000 R CNN
-F 2 "otter:C_0402" H 14600 8200 50  0001 C CNN
+F 2 "otter:R_0402" H 14600 8200 50  0001 C CNN
 F 3 "~" H 14600 8200 50  0001 C CNN
 	1    14600 8200
@@
 F 0 "R21" H 2292 9296 50  0000 R CNN
 F 1 "200k" H 2292 9205 50  0000 R CNN
-F 2 "otter:C_0402" H 2350 9250 50  0001 C CNN
+F 2 "otter:R_0402" H 2350 9250 50  0001 C CNN
 F 3 "~" H 2350 9250 50  0001 C CNN
 	1    2350 9250
@@
 F 0 "R24" V 3750 8000 50  0000 R CNN
 F 1 "5k1" V 3750 7700 50  0000 R CNN
-F 2 "otter:C_0402" H 3700 7800 50  0001 C CNN
+F 2 "otter:R_0402" H 3700 7800 50  0001 C CNN
 F 3 "~" H 3700 7800 50  0001 C CNN
 	1    3700 7800
@@
 F 0 "R25" V 3750 8100 50  0000 R CNN
 F 1 "5k1" V 3750 7800 50  0000 R CNN
-F 2 "otter:C_0402" H 3700 7900 50  0001 C CNN
+F 2 "otter:R_0402" H 3700 7900 50  0001 C CNN
 F 3 "~" H 3700 7900 50  0001 C CNN
 	1    3700 7900
@@
 F 0 "R14" H 1909 8004 50  0000 L CNN
 F 1 "5k1" H 1909 8095 50  0000 L CNN
-F 2 "otter:C_0402" H 1850 8050 50  0001 C CNN
+F 2 "otter:R_0402" H 1850 8050 50  0001 C CNN
 F 3 "~" H 1850 8050 50  0001 C CNN
 	1    1850 8050
@@
 F 0 "R22" V 3650 8400 50  0000 R CNN
 F 1 "DNP" V 3650 8100 50  0000 R CNN
-F 2 "otter:C_0402" H 3600 8200 50  0001 C CNN
+F 2 "otter:R_0402" H 3600 8200 50  0001 C CNN
 F 3 "~" H 3600 8200 50  0001 C CNN
 	1    3600 8200
@@
 F 0 "R23" V 3650 8500 50  0000 R CNN
 F 1 "DNP" V 3650 8200 50  0000 R CNN
-F 2 "otter:C_0402" H 3600 8300 50  0001 C CNN
+F 2 "otter:R_0402" H 3600 8300 50  0001 C CNN
 F 3 "~" H 3600 8300 50  0001 C CNN
 	1    3600 8300

Commit message: fixed axp bug, fixed schematics, fixed eeprom
Connections:
- net +3.3V_RTC: now also U3.29 (DC3SET)
- no-connect marks 10 -> 9
Changed lines of the file:
@@
 	3250 1550 3200 1550
 Connection ~ 5100 5850
-NoConn ~ 4450 5950
 Wire Wire Line
 	2050 4150 3250 4150
@@
 	1800 5400 1800 5300
 Connection ~ 1800 5300
+$Comp
+L S3-OLinuXino_Rev_A:+3.3V_RTC #PWR?
+U 1 1 602A517D
+P 4450 5950
+AR Path="/5D8A1FAC/602A517D" Ref="#PWR?"  Part="1"
+AR Path="/602A517D" Ref="#PWR?"  Part="1"
+AR Path="/602ACDF9/602A517D" Ref="#PWR0221"  Part="1"
+F 0 "#PWR0221" H 4450 5650 60  0001 C CNN
+F 1 "+3.3V_RTC" V 4465 6078 50  0000 L CNN
+F 2 "" H 4450 5950 60  0001 C CNN
+F 3 "" H 4450 5950 60  0001 C CNN
+	1    4450 5950
+	0    1    1    0
+$EndComp
 $EndSCHEMATC

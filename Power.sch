File: Power.sch (KiCad schematic (older format))
At the start: 80 parts, among them J3 USB, J4 OTG, Q1 DTA114YKA, SW1 DNP, SW2 DNP, SW3 RST, U1 AllWinner-S3(FBGA-234), U3 AXP209(QFN-48), U4 SY8089AAAC, U5 SY6280AAC

Commit message: fixed axp rst, gpio rst, din, dout, eth
Parts:
- removed SW1, SW2: DNP, otter:SW_SPST_PTS810, symbol Switch:SW_Push
- added C2: 470n, otter:C_0402, symbol Device:C_Small
- added R6: DNP, otter:R_0402, symbol Device:R_Small
Connections:
- net GND: now also C2.2
- net RESETn: now also C2.1
- net at Q1.1 (B): now also R6.1; no longer SW3.2
- new net GPIO-RST: R6.2, SW3.2
Other:
- moved on the sheet: C12, SW3
Changed lines of the file:
@@
 	1800 5750 1950 5750
-$Comp
-L Device:R_Small R?
-U 1 1 6629AA02
-P 2050 5550
-AR Path="/6629AA02" Ref="R?"  Part="1"
-AR Path="/602ACDF9/6629AA02" Ref="R17"  Part="1"
-F 0 "R17" V 2000 5400 50  0000 C CNN
-F 1 "2.2k" V 2000 5750 50  0000 C CNN
-F 2 "otter:R_0402" H 2050 5550 50  0001 C CNN
-F 3 "~" H 2050 5550 50  0001 C CNN
-	1    2050 5550
-	0    1    1    0
-$EndComp
-$Comp
-L S3-OLinuXino_Rev_A:GND #PWR?
-U 1 1 662BC85F
-P 1800 5550
-AR Path="/5D8A1FAC/662BC85F" Ref="#PWR?"  Part="1"
-AR Path="/662BC85F" Ref="#PWR?"  Part="1"
-AR Path="/602ACDF9/662BC85F" Ref="#PWR0164"  Part="1"
-F 0 "#PWR0164" H 1800 5300 50  0001 C CNN
-F 1 "GND" V 1805 5422 50  0000 R CNN
-F 2 "" H 1800 5550 60  0000 C CNN
-F 3 "" H 1800 5550 60  0000 C CNN
-	1    1800 5550
-	0    1    -1   0
-$EndComp
-Wire Wire Line
-	1800 5550 1950 5550
 $Comp
 L Device:Q_PNP_BEC_BRT Q1
@@
 	1    0    0    1
 $EndComp
-$Comp
-L Switch:SW_Push SW2
-U 1 1 6637168B
-P 1450 5250
-F 0 "SW2" H 1250 5300 50  0000 C CNN
-F 1 "DNP" H 1650 5300 50  0000 C CNN
-F 2 "otter:SW_SPST_PTS810" H 1450 5450 50  0001 C CNN
-F 3 "~" H 1450 5450 50  0001 C CNN
-	1    1450 5250
-	1    0    0    -1
-$EndComp
-$Comp
-L S3-OLinuXino_Rev_A:GND #PWR?
-U 1 1 663B8CCA
-P 1200 5250
-AR Path="/5D8A1FAC/663B8CCA" Ref="#PWR?"  Part="1"
-AR Path="/663B8CCA" Ref="#PWR?"  Part="1"
-AR Path="/602ACDF9/663B8CCA" Ref="#PWR0165"  Part="1"
-F 0 "#PWR0165" H 1200 5000 50  0001 C CNN
-F 1 "GND" V 1205 5122 50  0000 R CNN
-F 2 "" H 1200 5250 60  0000 C CNN
-F 3 "" H 1200 5250 60  0000 C CNN
-	1    1200 5250
-	0    1    -1   0
-$EndComp
-Wire Wire Line
-	1250 5250 1200 5250
 $Comp
 L Device:C_Small C?
@@
 Wire Wire Line
 	2050 3850 3250 3850
-$Comp
-L Switch:SW_Push SW1
-U 1 1 67020CA4
-P 2050 4950
-F 0 "SW1" H 1850 5000 50  0000 C CNN
-F 1 "DNP" H 2300 5000 50  0000 C CNN
-F 2 "otter:SW_SPST_PTS810" H 2050 5150 50  0001 C CNN
-F 3 "~" H 2050 5150 50  0001 C CNN
-	1    2050 4950
-	1    0    0    -1
-$EndComp
-$Comp
-L S3-OLinuXino_Rev_A:GND #PWR?
-U 1 1 67020CAA
-P 1800 4950
-AR Path="/5D8A1FAC/67020CAA" Ref="#PWR?"  Part="1"
-AR Path="/67020CAA" Ref="#PWR?"  Part="1"
-AR Path="/602ACDF9/67020CAA" Ref="#PWR0179"  Part="1"
-F 0 "#PWR0179" H 1800 4700 50  0001 C CNN
-F 1 "GND" V 1805 4822 50  0000 R CNN
-F 2 "" H 1800 4950 60  0000 C CNN
-F 3 "" H 1800 4950 60  0000 C CNN
-	1    1800 4950
-	0    1    -1   0
-$EndComp
-Wire Wire Line
-	1850 4950 1800 4950
-Wire Wire Line
-	3250 4950 2350 4950
-Connection ~ 2350 4950
-Wire Wire Line
-	2350 4950 2250 4950
-Wire Wire Line
-	2150 5550 3150 5550
 Wire Wire Line
 	3150 5500 3150 5550
@@
 L S3-OLinuXino_Rev_A:GND #PWR?
 U 1 1 6651D96D
-P 1800 5100
+P 1800 4950
 AR Path="/5D8A1FAC/6651D96D" Ref="#PWR?"  Part="1"
 AR Path="/6651D96D" Ref="#PWR?"  Part="1"
 AR Path="/602ACDF9/6651D96D" Ref="#PWR0166"  Part="1"
-F 0 "#PWR0166" H 1800 4850 50  0001 C CNN
-F 1 "GND" V 1805 4972 50  0000 R CNN
-F 2 "" H 1800 5100 60  0000 C CNN
-F 3 "" H 1800 5100 60  0000 C CNN
-	1    1800 5100
+F 0 "#PWR0166" H 1800 4700 50  0001 C CNN
+F 1 "GND" V 1805 4822 50  0000 R CNN
+F 2 "" H 1800 4950 60  0000 C CNN
+F 3 "" H 1800 4950 60  0000 C CNN
+	1    1800 4950
 	0    1    -1   0
 $EndComp
@@
 L Device:C_Small C?
 U 1 1 664B32D7
-P 2050 5100
+P 2050 4950
 AR Path="/664B32D7" Ref="C?"  Part="1"
 AR Path="/602ACDF9/664B32D7" Ref="C12"  Part="1"
-F 0 "C12" V 2000 4900 50  0000 L CNN
-F 1 "1n" V 2000 5150 50  0000 L CNN
-F 2 "otter:C_0402" H 2050 5100 50  0001 C CNN
-F 3 "~" H 2050 5100 50  0001 C CNN
-	1    2050 5100
+F 0 "C12" V 2000 4750 50  0000 L CNN
+F 1 "1n" V 2000 5000 50  0000 L CNN
+F 2 "otter:C_0402" H 2050 4950 50  0001 C CNN
+F 3 "~" H 2050 4950 50  0001 C CNN
+	1    2050 4950
 	0    1    1    0
 $EndComp
@@
 $EndComp
 Wire Wire Line
-	2150 5100 2350 5100
-Wire Wire Line
-	2350 4950 2350 5100
-Wire Wire Line
-	1800 5100 1950 5100
+	1800 4950 1950 4950
 Wire Wire Line
 	4450 1350 4450 1650
@@
 L Switch:SW_Push SW3
 U 1 1 601100C1
-P 1450 5400
-F 0 "SW3" H 1250 5450 50  0000 C CNN
-F 1 "RST" H 1650 5450 50  0000 C CNN
-F 2 "otter:SW_SPST_PTS810" H 1450 5600 50  0001 C CNN
-F 3 "~" H 1450 5600 50  0001 C CNN
-	1    1450 5400
+P 1100 5300
+F 0 "SW3" H 900 5350 50  0000 C CNN
+F 1 "RST" H 1300 5350 50  0000 C CNN
+F 2 "otter:SW_SPST_PTS810" H 1100 5500 50  0001 C CNN
+F 3 "~" H 1100 5500 50  0001 C CNN
+	1    1100 5300
 	1    0    0    -1
 $EndComp
@@
 L S3-OLinuXino_Rev_A:GND #PWR?
 U 1 1 60166E26
-P 1200 5400
+P 850 5300
 AR Path="/5D8A1FAC/60166E26" Ref="#PWR?"  Part="1"
 AR Path="/60166E26" Ref="#PWR?"  Part="1"
 AR Path="/602ACDF9/60166E26" Ref="#PWR0134"  Part="1"
-F 0 "#PWR0134" H 1200 5150 50  0001 C CNN
-F 1 "GND" V 1205 5272 50  0000 R CNN
-F 2 "" H 1200 5400 60  0000 C CNN
-F 3 "" H 1200 5400 60  0000 C CNN
-	1    1200 5400
+F 0 "#PWR0134" H 850 5050 50  0001 C CNN
+F 1 "GND" V 855 5172 50  0000 R CNN
+F 2 "" H 850 5300 60  0000 C CNN
+F 3 "" H 850 5300 60  0000 C CNN
+	1    850  5300
 	0    1    -1   0
 $EndComp
 Wire Wire Line
-	1200 5400 1250 5400
-Wire Wire Line
-	1800 5300 1800 5250
-Wire Wire Line
-	1800 5250 1650 5250
-Wire Wire Line
-	1800 5300 2750 5300
-Wire Wire Line
-	1650 5400 1800 5400
-Wire Wire Line
-	1800 5400 1800 5300
-Connection ~ 1800 5300
+	850  5300 900  5300
 $Comp
 L S3-OLinuXino_Rev_A:+3.3V_RTC #PWR?
@@
 	0    1    1    0
 $EndComp
+Wire Wire Line
+	2150 5550 3150 5550
+Wire Wire Line
+	1800 5550 1950 5550
+$Comp
+L S3-OLinuXino_Rev_A:GND #PWR?
+U 1 1 662BC85F
+P 1800 5550
+AR Path="/5D8A1FAC/662BC85F" Ref="#PWR?"  Part="1"
+AR Path="/662BC85F" Ref="#PWR?"  Part="1"
+AR Path="/602ACDF9/662BC85F" Ref="#PWR0164"  Part="1"
+F 0 "#PWR0164" H 1800 5300 50  0001 C CNN
+F 1 "GND" V 1805 5422 50  0000 R CNN
+F 2 "" H 1800 5550 60  0000 C CNN
+F 3 "" H 1800 5550 60  0000 C CNN
+	1    1800 5550
+	0    1    -1   0
+$EndComp
+$Comp
+L Device:R_Small R?
+U 1 1 6629AA02
+P 2050 5550
+AR Path="/6629AA02" Ref="R?"  Part="1"
+AR Path="/602ACDF9/6629AA02" Ref="R17"  Part="1"
+F 0 "R17" V 2000 5400 50  0000 C CNN
+F 1 "2.2k" V 2000 5750 50  0000 C CNN
+F 2 "otter:R_0402" H 2050 5550 50  0001 C CNN
+F 3 "~" H 2050 5550 50  0001 C CNN
+	1    2050 5550
+	0    1    1    0
+$EndComp
+Text GLabel 5450 1700 1    50   Input ~ 0
+RESETn
+$Comp
+L Device:C_Small C?
+U 1 1 6040E0D6
+P 5450 1800
+AR Path="/6040E0D6" Ref="C?"  Part="1"
+AR Path="/602ACDF9/6040E0D6" Ref="C2"  Part="1"
+F 0 "C2" H 5358 1846 50  0000 R CNN
+F 1 "470n" H 5358 1755 50  0000 R CNN
+F 2 "otter:C_0402" H 5450 1800 50  0001 C CNN
+F 3 "~" H 5450 1800 50  0001 C CNN
+	1    5450 1800
+	1    0    0    -1
+$EndComp
+$Comp
+L S3-OLinuXino_Rev_A:GND #PWR?
+U 1 1 6042CD5B
+P 5450 1900
+AR Path="/5D8A1FAC/6042CD5B" Ref="#PWR?"  Part="1"
+AR Path="/6042CD5B" Ref="#PWR?"  Part="1"
+AR Path="/602ACDF9/6042CD5B" Ref="#PWR0112"  Part="1"
+F 0 "#PWR0112" H 5450 1650 50  0001 C CNN
+F 1 "GND" H 5455 1727 50  0000 C CNN
+F 2 "" H 5450 1900 60  0000 C CNN
+F 3 "" H 5450 1900 60  0000 C CNN
+	1    5450 1900
+	-1   0    0    -1
+$EndComp
+Wire Wire Line
+	2150 4950 3250 4950
+Text GLabel 1300 5450 0    50   Input ~ 0
+GPIO-RST
+Wire Wire Line
+	1300 5450 1400 5450
+Wire Wire Line
+	1400 5450 1400 5300
+Wire Wire Line
+	1400 5300 1300 5300
+$Comp
+L Device:R_Small R?
+U 1 1 60580EA0
+P 2050 5300
+AR Path="/60580EA0" Ref="R?"  Part="1"
+AR Path="/602ACDF9/60580EA0" Ref="R6"  Part="1"
+F 0 "R6" V 2000 5150 50  0000 C CNN
+F 1 "DNP" V 2000 5500 50  0000 C CNN
+F 2 "otter:R_0402" H 2050 5300 50  0001 C CNN
+F 3 "~" H 2050 5300 50  0001 C CNN
+	1    2050 5300
+	0    1    1    0
+$EndComp
+Wire Wire Line
+	2150 5300 2750 5300
+Wire Wire Line
+	1950 5300 1400 5300
+Connection ~ 1400 5300
 $EndSCHEMATC

Commit message: added i2c to axp209, fixed tvs diodes
Parts:
- removed R19, R20: 2.2k, otter:R_0402, symbol Device:R_Small
Connections:
- net +5V_USBOTG: no longer D6.3 (A)
- net GND: now also D6.3 (A)
- net PB6\TWI0-SCK renamed MIPI-SCK
- net PB7\TWI0-SDA renamed MIPI-SDA
Changed lines of the file:
@@
 Text Notes 6000 5900 0    50   ~ 0
 1V3\n
-Text Label 2650 5850 0    50   ~ 0
-PB6\TWI0-SCK
-Text Label 2650 5950 0    50   ~ 0
-PB7\TWI0-SDA
-$Comp
-L Device:R_Small R?
-U 1 1 65EC7F5C
-P 2050 5850
-AR Path="/65EC7F5C" Ref="R?"  Part="1"
-AR Path="/602ACDF9/65EC7F5C" Ref="R19"  Part="1"
-F 0 "R19" V 2000 5700 50  0000 C CNN
-F 1 "2.2k" V 2000 6050 50  0000 C CNN
-F 2 "otter:R_0402" H 2050 5850 50  0001 C CNN
-F 3 "~" H 2050 5850 50  0001 C CNN
-	1    2050 5850
-	0    1    1    0
-$EndComp
-$Comp
-L Device:R_Small R?
-U 1 1 65EEA2F4
-P 2050 5950
-AR Path="/65EEA2F4" Ref="R?"  Part="1"
-AR Path="/602ACDF9/65EEA2F4" Ref="R20"  Part="1"
-F 0 "R20" V 2000 5800 50  0000 C CNN
-F 1 "2.2k" V 2000 6150 50  0000 C CNN
-F 2 "otter:R_0402" H 2050 5950 50  0001 C CNN
-F 3 "~" H 2050 5950 50  0001 C CNN
-	1    2050 5950
-	0    1    1    0
-$EndComp
-$Comp
-L S3-OLinuXino_Rev_A:+3.3V #PWR?
-U 1 1 65F75DFC
-P 1800 5850
-AR Path="/5D8A1FAC/65F75DFC" Ref="#PWR?"  Part="1"
-AR Path="/65F75DFC" Ref="#PWR?"  Part="1"
-AR Path="/602ACDF9/65F75DFC" Ref="#PWR0163"  Part="1"
-F 0 "#PWR0163" H 1800 5700 50  0001 C CNN
-F 1 "+3.3V" V 1815 5978 50  0000 L CNN
-F 2 "" H 1800 5850 60  0000 C CNN
-F 3 "" H 1800 5850 60  0000 C CNN
-	1    1800 5850
-	0    -1   1    0
-$EndComp
-Wire Wire Line
-	1950 5850 1850 5850
-Wire Wire Line
-	1850 5850 1850 5950
-Wire Wire Line
-	1850 5950 1950 5950
-Wire Wire Line
-	1850 5850 1800 5850
-Connection ~ 1850 5850
 Wire Wire Line
 	2150 5850 3250 5850
@@
 	0    -1   -1   0
 $EndComp
-$Comp
-L S3-OLinuXino_Rev_A:+5V_USBOTG #PWR?
-U 1 1 5FC176D0
-P 10850 10000
-AR Path="/5D8A1FAC/5FC176D0" Ref="#PWR?"  Part="1"
-AR Path="/5FC176D0" Ref="#PWR?"  Part="1"
-AR Path="/602ACDF9/5FC176D0" Ref="#PWR0110"  Part="1"
-F 0 "#PWR0110" H 10850 9850 50  0001 C CNN
-F 1 "+5V_USBOTG" V 10850 10150 50  0000 L CNN
-F 2 "" H 10850 10000 60  0000 C CNN
-F 3 "" H 10850 10000 60  0000 C CNN
-	1    10850 10000
-	0    1    1    0
-$EndComp
 Connection ~ 3400 8300
 Connection ~ 3400 8200
@@
 	1950 5300 1400 5300
 Connection ~ 1400 5300
+$Comp
+L otter:GND #PWR?
+U 1 1 6036508A
+P 10850 10000
+AR Path="/6036508A" Ref="#PWR?"  Part="1"
+AR Path="/602ACDF9/6036508A" Ref="#PWR0115"  Part="1"
+F 0 "#PWR0115" H 10850 9750 50  0001 C CNN
+F 1 "GND" V 10855 9872 50  0000 R CNN
+F 2 "" H 10850 10000 60  0000 C CNN
+F 3 "" H 10850 10000 60  0000 C CNN
+	1    10850 10000
+	0    -1   -1   0
+$EndComp
+Text GLabel 2150 5950 0    50   Input ~ 0
+MIPI-SDA
+Text GLabel 2150 5850 0    50   Input ~ 0
+MIPI-SCK
 $EndSCHEMATC
